
#PACKAGECONFIG ??= "libsodium"
#PACKAGECONFIG[zeromq] += "-DENABLE_DRAFTS=ON"

EXTRA_OECMAKE += " -DENABLE_DRAFTS=ON "
