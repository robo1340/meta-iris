## conf/machine/iris-machine.conf
```bitbake
require conf/machine/stm32mp13-disco.conf

KERNEL_DEVICETREE = "iris.dtb"

IMAGE_INSTALL:append = " u-boot-fw-utils "
```
