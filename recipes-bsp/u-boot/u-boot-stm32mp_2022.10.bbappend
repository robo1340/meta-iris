FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

#SRC_URI += "file://0001-ENV_OFFSET_changed_stm32mp13_defconfig.patch"

